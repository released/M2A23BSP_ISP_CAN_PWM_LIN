# Keil uVision project Template.uvprojx, settings and files
target Template (6220000::V6.22::ARMCLANG)
  device: M2A23LD5AC Nuvoton
  pack: Nuvoton.NuMicroM23_DFP.1.0.7
  cpu: IRAM(0x20000000,0x6000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M23") CLOCK(12000000)
  output: LDROM_Bootloader +hex
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=7 OneElfS=1 v6Lang=1 v6LangP=1 v6Lto=1
  c include: ..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\Device\Nuvoton\m2a23\Include;..\..\..\..\Library\StdDriver\inc;..\..\ISP_CAN;..\..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x6000
  link misc: --map --first='startup_m2a23.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/m2a23/Source/ARM/: startup_m2a23.S
    ../../../../Library/Device/Nuvoton/m2a23/Source/: system_m2a23.c
  group User
    ../: main.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c sys.c fmc.c canfd.c
